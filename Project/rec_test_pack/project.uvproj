# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,HAVE_CONFIG_H
  c include: .;..\..\RTT\components\dfs;..\..\RTT\components\dfs\include;..\..\RTT\components\drivers\include;..\..\RTT\components\finsh;..\..\RTT\include;..\..\RTT\libcpu\arm\common;..\..\RTT\libcpu\arm\cortex-m4;STM32F4xx_Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;STM32F4xx_Libraries\CMSIS\Include;STM32F4xx_Libraries\CMSIS\ST\STM32F4xx\Include;STM32F4xx_Libraries\STM32F4xx_StdPeriph_Driver\inc;applications;drivers;.\applications\speex-1.2rc1\include;.\applications\speex-1.2rc1\libspeex;.\applications\speex-1.2rc1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c fs_rw_test.c startup.c wav.c
  group Drivers
    drivers/: board.c codec_wm8978_i2c.c ext_sram.c ra8875.c sdio_sd.c serial.c stm32_i2c.c stm32f4xx_it.c usart.c
  group STM32_StdPeriph
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    STM32F4xx_Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    STM32F4xx_Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    ../../RTT/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../RTT/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../RTT/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../RTT/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../RTT/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ../../RTT/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
  group finsh
    ../../RTT/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group speex
    ./applications/speex-1.2rc1/libspeex/: quant_lsp.c nb_celp.c modes.c ltp.c filters.c cb_search.c vq.c window.c vbr.c speex_header.c speex_callbacks.c speex.c smallft.c sb_celp.c resample.c stereo.c modes_wb.c lsp.c lpc.c kiss_fftr.c lsp_tables_nb.c jitter.c high_lsp_tables.c hexc_table.c hexc_10_32_table.c gain_table_lbr.c gain_table.c filterbank.c kiss_fft.c exc_10_32_table.c exc_10_16_table.c exc_8_128_table.c exc_5_256_table.c exc_5_64_table.c exc_20_32_table.c buffer.c bits.c
